# Keil uVision project projectReaction.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: NUC140VE3CN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.10
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: projectReaction
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: C:\Nuvoton\NUC140BSP_EDU\Library\CMSIS\Include;C:\Nuvoton\NUC140BSP_EDU\Library\Device\Nuvoton\NUC1xx\Include;C:\Nuvoton\NUC140BSP_EDU\Library\NUC1xx\Source;C:\Nuvoton\NUC140BSP_EDU\Library;C:\Nuvoton\NUC140BSP_EDU\Library\NUC1xx\Include;C:\Nuvoton\NUC140BSP_EDU\Library\NUC1xx-LB_002\Include
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_NUC1xx.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group Source
    C:/Nuvoton/NUC140BSP_EDU/Library/NUC1xx-LB_002/Source/: Scankey.c Seven_Segment.c LCD.c
    ./: main.c
  group CMSIS Group
    C:/Nuvoton/NUC140BSP_EDU/Library/CMSIS/Include/: core_cm0.c
    C:/Nuvoton/NUC140BSP_EDU/Library/Device/Nuvoton/NUC1xx/Source/arm/: startup_NUC1xx.s
    C:/Nuvoton/NUC140BSP_EDU/Library/Device/Nuvoton/NUC1xx/Source/: system_NUC1xx.c
  group Library
    C:/Nuvoton/NUC140BSP_EDU/Library/NUC1xx/Source/: GPIO.c SPI.c SYS.c CAN.c TIMER.c
